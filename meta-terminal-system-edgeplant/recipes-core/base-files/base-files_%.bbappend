do_install_bind_mount_var_lib:edgeplant-r1() {
    # Do not bind-mount the directory under /var/lib to the data partition, but bind-mount it to the SD.
    :
}
