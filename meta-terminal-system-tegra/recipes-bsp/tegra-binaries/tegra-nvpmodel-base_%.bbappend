NVPMODEL_CONFIG_DEFAULT = "0"
