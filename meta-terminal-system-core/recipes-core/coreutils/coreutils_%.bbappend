FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

ALTERNATIVE_PRIORITY = "400"
