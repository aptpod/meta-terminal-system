CMDLINE:append = " fsck.repair=yes"
